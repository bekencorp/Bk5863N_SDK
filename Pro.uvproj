# Keil uVision project Pro.uvproj, settings and files
target obu_full_code (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: Bk5863N +hex
  AfterMake: .\Build\tool\full_code_translate.bat
  c flags: Optim=1
  c define: RELEASE,BK5863N
  c misc: --c99
  c include: .\User;..\BK5863N;.\User\FWlib;.\User\Test;.\User\Drive;.\User\ATE;.\User\mem;.\User\demo\test;.\ls_beken\func\su_cli;.\ls_beken\app;.\ls_beken\common;.\ls_beken\kernel;.\ls_beken\app\obu_app;.\ls_beken\driver\isoiec7816;.\ls_beken\func\sl_esam;.\ls_beken\func\des;.\ls_beken\func\des;.\ls_beken\func\sw_des;.\ls_beken\app\esam_5121;.\ls_beken\func\fake_timer;.\ls_beken\func\misc;.\ls_beken\func\dsrc;.\ls_beken\app\dsrc_app;.\ls_beken\app\esam_app;.\ls_beken\app\icc_app
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x400000 size 0x2000
  scatter file: .\Build\Lds\full_code_linke.ini
  link misc: --entry=0x0
  group app
    ./ls_beken/app/: ke_app.c
    ./ls_beken/kernel/: ke_event.c com_op_math.c
    ./ls_beken/app/obu_app/: obu_app.c
    ./ls_beken/app/esam_5121/: app_esam_5121.c
    ./ls_beken/app/dsrc_app/: dsrc_app.c dsrc_app_intf.c dsrc_app_item1.c
    ./ls_beken/app/esam_app/: esam_app.c
    ./ls_beken/app/icc_app/: icc_app.c icc_m1.c
  group func
    ./ls_beken/func/su_cli/: su_cli.c su_cli_intf.c su_hex_core.c su_str_core.c
    ./ls_beken/func/sl_esam/: sl_esam.c
    ./ls_beken/func/des/: sl_des.c
    ./ls_beken/func/sw_des/: sw_des_test.c sw_des.c
    ./ls_beken/func/fake_timer/: fake_timer.c
    ./ls_beken/func/misc/: fake_clock.c
    ./ls_beken/func/dsrc/: dsrc_mac.c dsrc.c dsrc_llc.c dsrc_lsdu.c dsrc_intf.c
  group driver
    ./ls_beken/driver/isoiec7816/: isoiec7816.c isoiec7816_intf.c
  group USER
    ./User/: main.c target.c BK5863_it.c UART_Config.c
    ./User/mem/: mmgmt.c
  group Test
    ./User/Test/: BKTestAPP.c BKTestD.c BK5824Test.c BKCardTest.c FlashConfig.c BKDACTest.c EEPROM.c
    ./User/demo/test/: test.c
  group Drive
    ./User/FWlib/: SysConfig.c
    ./User/Drive/: SPIConfig.c IICconfig.c BK5824Config.c BK5824RegMem.c ADCConfig.c PWMConfig.c DACConfig.c TDesConfig.c CardConfig.c CRCconfig.c GPIOConfig.c UARTConfig.c Sim7816.c BKmem.c SysSleep.c SystemConfig.c CPUCardConfig.c
  group FWlib
    ./User/: SysTime.c Init.s Vectors.s
    ./User/FWlib/: UART.c BK5824D.c SPI.c misc.c BK5863_GPIO.c WDT.c BKCard.c IIC.c ADC.c DAC.c TDes.c Flash.c Calibration.c CRC.c LBD.c TIM.c ClkOutput.c
  group ATE
    ./User/ATE/: ATEcalibration.c ATE.c
